# Keil uVision project lowersystem.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205RETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lowersystem +hex
  AfterMake: fromelf.exe --bin -o .\Objects\@L.bin .\Objects\@L.axf
  AfterMake: ..\..\..\tools\srecord-1.63-win32\srec_cat .\Objects\@L.hex -intel -o .\Objects\@L.srec
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F205xx,MX_TB,USING_OS_FREERTOS
  c include: ..\..\..\sdk\STM32Cube_FW_F2_V1.8.0\Drivers\CMSIS\Include;..\..\..\sdk\STM32Cube_FW_F2_V1.8.0\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\sdk\STM32Cube_FW_F2_V1.8.0\Drivers\STM32F2xx_HAL_Driver\Inc;..\..\..\sdk\STM32Cube_FW_F2_V1.8.0\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\sdk\STM32Cube_FW_F2_V1.8.0\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\bsp\inc;..\..\..\middleware;inc
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ./src/: startup_stm32f205xx.s system_stm32f2xx.c
  group Dirver
    ../../../sdk/STM32Cube_FW_F2_V1.8.0/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_cryp.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_dcmi.c stm32f2xx_hal_dcmi_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_exti.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hash.c stm32f2xx_hal_hcd.c stm32f2xx_hal_i2c.c stm32f2xx_hal_i2s.c stm32f2xx_hal_irda.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_mmc.c stm32f2xx_hal_nand.c stm32f2xx_hal_nor.c stm32f2xx_hal_pccard.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_smartcard.c stm32f2xx_hal_spi.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_usart.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_adc.c stm32f2xx_ll_crc.c stm32f2xx_ll_dac.c stm32f2xx_ll_dma.c stm32f2xx_ll_exti.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_gpio.c stm32f2xx_ll_i2c.c stm32f2xx_ll_pwr.c stm32f2xx_ll_rcc.c stm32f2xx_ll_rng.c stm32f2xx_ll_rtc.c stm32f2xx_ll_sdmmc.c stm32f2xx_ll_spi.c stm32f2xx_ll_tim.c stm32f2xx_ll_usart.c stm32f2xx_ll_usb.c stm32f2xx_ll_utils.c
    ../../../sdk/STM32Cube_FW_F2_V1.8.0/Drivers/STM32F2xx_HAL_Driver/Src/Legacy/: stm32f2xx_hal_can.c
  group RTOS
    ../../../sdk/STM32Cube_FW_F2_V1.8.0/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../sdk/STM32Cube_FW_F2_V1.8.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../sdk/STM32Cube_FW_F2_V1.8.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group BSP
    ../../../bsp/src/stm32f2xx/: board_stm32f2xx.c can_stm32f2xx.c i2c_stm32f2xx.c uart_stm32f2xx.c
    ../../../bsp/src/: can.c i2c.c uart.c
  group Middleware
    ../../../middleware/diag/isotp/: isotp.c
    ../../../middleware/diag/: diag.c diag_client.c diag_server.c
    ../../../middleware/resolve/: gen_resolve.c resolve.c
    ../../../middleware/bitfield/: 8byte.c bitarray.c bitfield.c
    ../../../middleware/nm/: osek_nm.c
  group User
    ../../: main.c
    ../: rtos.c
